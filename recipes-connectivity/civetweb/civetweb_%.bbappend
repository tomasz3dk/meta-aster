PACKAGECONFIG_append = " cpp"
