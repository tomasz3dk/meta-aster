DEPENDS += "bootfiles"

IMAGE_INSTALL += " \
    qt5-env \
"