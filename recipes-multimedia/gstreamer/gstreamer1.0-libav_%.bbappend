PACKAGECONFIG_append = " gpl"
