PACKAGECONFIG_append = " ivorbis"
