PACKAGECONFIG_append_raspberrypi3 = " vpx wavpack"
