PACKAGECONFIG_remove = " sdl2"
